Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Wash-Basins_Ceramica-Catalano_New-Green-Lavabo-A-50.ifc
Time: 2022-09-12T11:32:19
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: New Green Lavabo A 50
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): New Green Lavabo A 50; SKU (BO_prodsku): catalano_NEW_GREEN; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Ceramica Catalano; ProductGroup (BO_prodgroup): Basin; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 1; Height (BO_height): 1; Depth (BO_depth): 1; Weight (BO_weight): 1; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_NEW_GREEN; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_NEW_GREEN; ProductCertification (BO_prodcert): http://www.ceramicacatalano.it/conformita/Declaration-of-Performance-Washbasin.pdf; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/PREMIUM/110VP00.pdf; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Fireclay; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Wash Basins; BimObjectCategoryCode (BO_bocat_code): wash-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass14Code (BO_uniclass_1_4_code): L721; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary equipment; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
